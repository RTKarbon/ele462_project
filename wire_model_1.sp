* Code generated by MATLAB
.param vdd=1.2V
R1 1 2 1.088255e-01
R2 3 4 1.015319e-01
R3 5 6 1.042988e-01
R4 7 8 1.196746e-01
R5 9 10 1.028202e-01
R6 11 12 1.174601e-01
R7 13 14 1.107299e-01
R8 15 16 1.218478e-01
R9 17 18 1.014272e-01
R10 19 20 1.086581e-01
L1 2 3 1.000000e-03
L2 4 5 1.000000e-03
L3 6 7 1.000000e-03
L4 8 9 1.000000e-03
L5 10 11 1.000000e-03
L6 12 13 1.000000e-03
L7 14 15 1.000000e-03
L8 16 17 1.000000e-03
L9 18 19 1.000000e-03
L10 20 21 1.000000e-03
C1 3 GND 9.189025e-02
C2 5 GND 9.849122e-02
C3 7 GND 9.587841e-02
C4 9 GND 8.355993e-02
C5 11 GND 9.725720e-02
C6 13 GND 8.513529e-02
C7 15 GND 9.030984e-02
C8 17 GND 8.206958e-02
C9 19 GND 9.859284e-02
C10 21 GND 9.203179e-02
VSW 1 0 PULSE (0V vdd 5ns 50ns 50ns 45ns 100ns)
.options nomod post
.tran 1ps 500ns
.END wire_model_1
